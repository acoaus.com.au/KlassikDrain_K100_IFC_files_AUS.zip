Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: eb084157-b874-49a9-a16a-e96f7d606e19, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site]
File name: 142838.ifc
Time: 2026-02-16T15:25:27+05:30
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.80.30 (ENU) - IFC 23.4.1.0

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuildingStorey: Level:8mm Head (2)
Name | LongName | Elevation (mm)
Level 1 | Level 1 | 0
Level 2 | Level 2 | 4000

# IfcDistributionPort, OutPort_370679_1
Description: Flow; FlowDirection: SOURCE

# IfcFlowTerminal: KlassikDrain_K1-900G_In-line_pit:K1-900G In-line pit (0.5m), KlassikDrain_K1-900G_In-line_pit:K1-900G In-line pit (0.5m):370679
In: Level 1
Type - Description: ACO K1-900G In-line pit (0.5m); PredefinedType: USERDEFINED; Material: polymer concrete, Steel, Galvanised
KlassikDrain_K100 - code_supplier_article_C_ANZRS: 142838; item_description: ACO K1-900G In-line pit (0.5m); net_mass_S_ANZRS: 29.5 kg; Manufacturer: ACO

# IfcFlowTerminal: ZZZ_do not use_PF_ST_KlassikDrain_K100_In-line_pit_gratings_ACO:std(nested), ZZZ_do not use_PF_ST_KlassikDrain_K100_In-line_pit_gratings_ACO:std(nested):370680
In: Level 1
Type - Description: ACO Grating for KlassikDrain_K100; Material: Steel, Stainless
KlassikDrain_K100 - code_supplier_article_C_ANZRS: 12611; item_description: Type 421D Galvanised Steel Slotted grate (0.5m); net_mass_S_ANZRS: 1.4 kg; LOD: LOD 300; Manufacturer: ACO
