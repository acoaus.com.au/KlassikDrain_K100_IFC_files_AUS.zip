Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: eb084157-b874-49a9-a16a-e96f7d606e19, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site]
File name: 144039.ifc
Time: 2026-02-16T14:25:35+05:30
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.80.30 (ENU) - IFC 23.4.1.0

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuildingStorey: Level:8mm Head (2)
Name | LongName | Elevation (mm)
Level 1 | Level 1 | 0
Level 2 | Level 2 | 4000

# IfcFlowTerminal: PF_ST_KlassikDrain_K100 & KS100_channels_AUS_ACO:KlassikDrain_K100_Invert_Depth_250mm to 300mm, PF_ST_KlassikDrain_K100 & KS100_channels_AUS_ACO:KlassikDrain_K100_Invert_Depth_250mm to 300mm:359272
In: Level 1
Type - Description: ACO KlassikDrain K100/KS100 channels; PredefinedType: USERDEFINED; Material: Steel, Galvanised, polymer concrete
KlassikDrain_K100 - code_supplier_article_C_ANZRS: 144039; item_description: K1-39 Sloped channel - (1m); net_mass_S_ANZRS: 26.6 kg; LOD: LOD 300; Manufacturer: ACO

# IfcFlowTerminal: ZZZ_do not use_PF_ST_KlassikDrain_K100_gratings_ACO:std(nested) (2)
In: Level 1
Type - Description: ACO Grating for KlassikDrain_K100; Material: Steel, Galvanised
KlassikDrain_K100 - code_supplier_article_C_ANZRS: 12615; item_description: Type 426D Galvanised Slotted grate (0.5m); net_mass_S_ANZRS: 2 kg; LOD: LOD 300; Manufacturer: ACO
Name (ZZZ_do not use_PF_ST_KlassikDrain_K100_gratings_ACO:std(nested):...)
359273
360678
