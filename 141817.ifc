Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: eb084157-b874-49a9-a16a-e96f7d606e19, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site]
File name: 141817.ifc
Time: 2026-02-16T15:28:43+05:30
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.80.30 (ENU) - IFC 23.4.1.0

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuildingStorey: Level:8mm Head (2)
Name | LongName | Elevation (mm)
Level 1 | Level 1 | 0
Level 2 | Level 2 | 4000

# IfcDistributionPort (15)
Description: Flow; FlowDirection: SOURCE
Name
OutPort_379497_1
OutPort_379497_2
OutPort_379497_3
OutPort_379497_4
OutPort_379497_5
OutPort_379497_6
OutPort_379497_7
OutPort_379497_8
OutPort_379497_9
OutPort_379497_10
OutPort_379497_11
OutPort_379497_12
OutPort_379497_13
OutPort_379497_14
OutPort_379497_15

# IfcFlowTerminal: KlassikDrain_K1-901G_In-line_pit:K1-901G In-line pit (0.5m), KlassikDrain_K1-901G_In-line_pit:K1-901G In-line pit (0.5m):379497
In: Level 1
Type - Description: ACO K1-901G In-line pit (0.5m); PredefinedType: USERDEFINED; Material: PE, Black, polymer concrete, Steel, Galvanised
KlassikDrain_K100 - code_supplier_article_C_ANZRS: 141817; item_description: ACO K1-901G In-line pit (0.5m); net_mass_S_ANZRS: 23.9 kg; Manufacturer: ACO

# IfcFlowTerminal: ZZZ_do not use_PF_ST_KlassikDrain_K100_In-line_pit_gratings_ACO:std(nested), ZZZ_do not use_PF_ST_KlassikDrain_K100_In-line_pit_gratings_ACO:std(nested):379499
In: Level 1
Type - Description: ACO Grating for KlassikDrain_K100; Material: Steel, Galvanised
KlassikDrain_K100 - code_supplier_article_C_ANZRS: 142570; item_description: Type 440D Stainless Splitwire Heelsafe® Anti-Slip grate (0.5m); net_mass_S_ANZRS: 2.2 kg; LOD: LOD 300; Manufacturer: ACO
